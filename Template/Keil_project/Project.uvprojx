# Keil uVision project Project.uvprojx, settings and files
target GD32470I_EVAL (6220000::V6.22::ARMCLANG)
  device: GD32F470IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F470,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE,LV_DEMO_CONF_INCLUDE_SIMPLE
  c include: ..\;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\Firmware\GD32F4xx_standard_peripheral\Include;..\..\Utilities\lvgl\lvgl;..\..\Utilities\lvgl\lvgl_port;..\GUI_APP\ui_lvgl\demos;..\..\Utilities\bsp_drive;..\..\Utilities\fatfs\fatfs;..\..\Utilities\fatfs\fatfs_port;..\..\Utilities\freertos\freertos\include;..\..\Utilities\freertos\freertos_port;..\GUI_APP\ui_lvgl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Project.sct
  group Application
    ../: main.c gd32f4xx_it.c systick.c taskmain.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Peripherals
    ../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group bsp_drive
    ../../Utilities/bsp_drive/: exmc_sdram.c gd32f450i_lcd_eval.c gd32f470i_eval.c lcd_font.c touch_panel.c bsp_adc.c sdcard.c gd25qxx.c
  group lvgl
    ../../Utilities/lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../Utilities/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Utilities/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../Utilities/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Utilities/lvgl/lvgl/src/extra/: lv_extra.c
    ../../Utilities/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../Utilities/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Utilities/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Utilities/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../Utilities/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Utilities/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../Utilities/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../Utilities/lvgl/lvgl/src/extra/others/msg/: lv_msg.c
    ../../Utilities/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/led/: lv_led.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/win/: lv_win.c
    ../../Utilities/lvgl/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../Utilities/lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../Utilities/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../Utilities/lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl_port
    ../../Utilities/lvgl/lvgl_port/: lv_port_disp.c lv_port_indev.c
  group ui_app
    ../GUI_APP/ui_lvgl/: fatfs_file_browse.c lv_about.c lv_demo_app.c lv_demo_picture.c lv_demo_qrcode.c lv_demo_setting.c lv_file_browse.c
    ../../Template/GUI_APP/ui_lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../../Template/GUI_APP/ui_lvgl/demos/benchmark/assets/: lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../../Template/GUI_APP/ui_lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../../Template/GUI_APP/ui_lvgl/demos/stress/: lv_demo_stress.c
    ../../Template/GUI_APP/ui_lvgl/demos/widgets/: lv_demo_widgets.c
  group ui_resource
    ../GUI_APP/ui_lvgl/assets/Image/: img_about.c img_background.c img_bmp.c img_file.c img_gd_logo.c img_home.c img_mem.c img_music.c img_picture.c img_png.c img_qrcode.c img_setting.c img_speed.c img_sjpg.c img_temp.c img_widget.c wave.c meiguo_32.c riben_32.c wuxinghongqi_32.c deguo_32.c japan_tanugo_reg_10.c yahei_regular_10.c image_file_28.c image_folder_28.c lv_font_digital_20.c lv_font_digital_30.c lv_customer_font_SourceHanSerifSC_Regular_10.c
    ../../Template/GUI_APP/ui_lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c
    ../../Template/GUI_APP/ui_lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../../Template/GUI_APP/ui_lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group fatfs
    ../../Utilities/fatfs/fatfs/: ff.c ffsystem.c ffunicode.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Doc
    ../../: README.md
  group fatfs_port
    ../../Utilities/fatfs/fatfs_port/: diskio.c
software components: CMSIS:CORE 6.1.0
