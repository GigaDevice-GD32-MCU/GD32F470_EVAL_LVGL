# IAR project GD32F470I_EVAL.ewp, settings and files
configuration GD32F470 (ARM, debug)
  General.OGChipSelectEditMenu: GD32F470xK GD GD32F470xK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32F470; LV_LVGL_H_INCLUDE_SIMPLE; LV_CONF_INCLUDE_SIMPLE
  ICCARM.CCDiagSuppress: Pe177,Pa089,Pe236,Pe546,Pa084,Pe111,Pe188,Pa118,Pe550,Pe186,Pa093,Pe549,Pa167,Pe170,Pe191
  ICCARM.CCIncludePath2: ..; ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\Firmware\GD32F4xx_standard_peripheral\Include; ..\..\Utilities\lvgl; ..\..\Utilities\lvgl\lvgl; ..\..\Utilities\lvgl\lvgl_port; ..\GUI_APP\ui_lvgl\demos; ..\..\Utilities\bsp_drive; ..\..\Utilities\fatfs\fatfs; ..\..\Utilities\fatfs\fatfs_port; ..\..\Utilities\freertos\freertos\include; ..\..\Utilities\freertos\freertos_port; ..\GUI_APP\ui_lvgl
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32F470I_EVAL.srec
  ILINK.IlinkOutputFile: GD32F470I_EVAL.out
  ILINK.IlinkIcfFile: GD32F470xK_custom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32f4xx_it.c main.c systick.c taskmain.c
  group bsp_drive
    ../../Utilities/bsp_drive/: bsp_adc.c exmc_sdram.c gd25qxx.c gd32f450i_lcd_eval.c gd32f470i_eval.c lcd_font.c sdcard.c touch_panel.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Doc
    ../../: README.md
  group fatfs
    ../../Utilities/fatfs/fatfs/: ff.c ffsystem.c ffunicode.c
  group fatfs_port
    ../../Utilities/fatfs/fatfs_port/: diskio.c
  group lvgl
    ../../Utilities/lvgl/lvgl/src/libs/gif/: gif.c
    ../../Utilities/lvgl/lvgl/src/libs/lodepng/: lodepng.c
    ../../Utilities/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../Utilities/lvgl/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../Utilities/lvgl/lvgl/src/widgets/arc/: lv_arc.c
    ../../Utilities/lvgl/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../Utilities/lvgl/lvgl/src/widgets/bar/: lv_bar.c
    ../../Utilities/lvgl/lvgl/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_lodepng.c lv_tjpgd.c
    ../../Utilities/lvgl/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../../Utilities/lvgl/lvgl/src/widgets/button/: lv_button.c
    ../../Utilities/lvgl/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../Utilities/lvgl/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/lvgl/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Utilities/lvgl/lvgl/src/widgets/chart/: lv_chart.c
    ../../Utilities/lvgl/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Utilities/lvgl/lvgl/src/display/: lv_display.c
    ../../Utilities/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    ../../Utilities/lvgl/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../Utilities/lvgl/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Utilities/lvgl/lvgl/src/layouts/flex/: lv_flex.c
    ../../Utilities/lvgl/lvgl/src/font/: lv_font.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../Utilities/lvgl/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../../Utilities/lvgl/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Utilities/lvgl/lvgl/src/fs/: lv_fs.c lv_fs_fatfs.c
    ../../Utilities/lvgl/lvgl/src/widgets/gif/: lv_gif.c
    ../../Utilities/lvgl/lvgl/src/layouts/grid/: lv_grid.c
    ../../Utilities/lvgl/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../Utilities/lvgl/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../../Utilities/lvgl/lvgl/src/widgets/image/: lv_image.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../Utilities/lvgl/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Utilities/lvgl/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../../Utilities/lvgl/lvgl/src/font/imgfont/: lv_imgfont.c
    ../../Utilities/lvgl/lvgl/src/: lv_init.c
    ../../Utilities/lvgl/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/lvgl/lvgl/src/widgets/label/: lv_label.c
    ../../Utilities/lvgl/lvgl/src/layouts/: lv_layout.c
    ../../Utilities/lvgl/lvgl/src/widgets/led/: lv_led.c
    ../../Utilities/lvgl/lvgl/src/widgets/line/: lv_line.c
    ../../Utilities/lvgl/lvgl/src/widgets/list/: lv_list.c
    ../../Utilities/lvgl/lvgl/src/logging/: lv_log.c
    ../../Utilities/lvgl/lvgl/src/stdlib/: lv_mem.c
    ../../Utilities/lvgl/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Utilities/lvgl/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../Utilities/lvgl/lvgl/src/widgets/menu/: lv_menu.c
    ../../Utilities/lvgl/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/lvgl/lvgl/src/osal/: lv_os.c lv_os_none.c
    ../../Utilities/lvgl/lvgl/src/widgets/qrcode/: lv_qrcode.c
    ../../Utilities/lvgl/lvgl/src/widgets/roller/: lv_roller.c
    ../../Utilities/lvgl/lvgl/src/widgets/scale/: lv_scale.c
    ../../Utilities/lvgl/lvgl/src/widgets/slider/: lv_slider.c
    ../../Utilities/lvgl/lvgl/src/draw/snapshot/: lv_snapshot.c
    ../../Utilities/lvgl/lvgl/src/widgets/span/: lv_span.c
    ../../Utilities/lvgl/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/lvgl/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Utilities/lvgl/lvgl/src/widgets/switch/: lv_switch.c
    ../../Utilities/lvgl/lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../../Utilities/lvgl/lvgl/src/widgets/table/: lv_table.c
    ../../Utilities/lvgl/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Utilities/lvgl/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Utilities/lvgl/lvgl/src/themes/: lv_theme.c
    ../../Utilities/lvgl/lvgl/src/themes/default/: lv_theme_default.c
    ../../Utilities/lvgl/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../Utilities/lvgl/lvgl/src/themes/simple/: lv_theme_simple.c
    ../../Utilities/lvgl/lvgl/src/tick/: lv_tick.c
    ../../Utilities/lvgl/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Utilities/lvgl/lvgl/src/widgets/win/: lv_win.c
    ../../Utilities/lvgl/lvgl/src/libs/qrcode/: qrcodegen.c
    ../../Utilities/lvgl/lvgl/src/libs/tjpgd/: tjpgd.c
  group lvgl_port
    ../../Utilities/lvgl/lvgl_port/: lv_port_disp.c lv_port_indev.c
  group Peripherals
    ../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450_470.s
  group ui_app
    ../GUI_APP/ui_lvgl/: fatfs_file_browse.c lv_about.c lv_demo_app.c lv_demo_picture.c lv_demo_qrcode.c lv_demo_setting.c lv_file_browse.c
    ../GUI_APP/ui_lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../GUI_APP/ui_lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../GUI_APP/ui_lvgl/demos/stress/: lv_demo_stress.c
    ../GUI_APP/ui_lvgl/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
    ../GUI_APP/ui_lvgl/demos/: lv_demos.c
  group ui_resource
    ../GUI_APP/ui_lvgl/assets/Image/: deguo_32.c image_file_28.c image_folder_28.c img_about.c img_background.c img_bmp.c img_file.c img_gd_logo.c img_home.c img_mem.c img_music.c img_picture.c img_png.c img_qrcode.c img_setting.c img_sjpg.c img_speed.c img_temp.c img_widget.c japan_tanugo_reg_10.c lv_customer_font_SourceHanSerifSC_Regular_10.c lv_font_digital_20.c lv_font_digital_30.c meiguo_32.c riben_32.c wave.c wuxinghongqi_32.c yahei_regular_10.c
    ../GUI_APP/ui_lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
    ../GUI_APP/ui_lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    ../GUI_APP/ui_lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
